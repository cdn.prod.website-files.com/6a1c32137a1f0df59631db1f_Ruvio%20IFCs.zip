Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: D:\Dropbox (Personal)\Projects\Kinley\Remodels\IFC PARTS\06.076.S (IFC v2.IFC
Time: 2026-05-20T15:31:22+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
