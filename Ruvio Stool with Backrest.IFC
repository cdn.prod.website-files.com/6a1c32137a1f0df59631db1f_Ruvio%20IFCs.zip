Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: D:\Dropbox (Personal)\Projects\Kinley\Remodels\IFC PARTS\02.676 (ifc v2).IFC
Time: 2026-05-20T14:54:11+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
