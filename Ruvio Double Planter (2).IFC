Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: D:\Dropbox (Personal)\Projects\Kinley\Remodels\IFC PARTS\06.176.XL (IFC).IFC
Time: 2026-05-21T07:45:45+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
